Commit message: Update submodules

File: youbot_simulation/youbot_gazebo_worlds/urdf/robocup.urdf (robot description, URDF)
Before this commit: robot arena, 10 links, 9 joints
Links:
- link wall_1: mass 10.0 -> 1000.0
